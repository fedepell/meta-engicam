
FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"

SRC_URI += " file://gcc10_build.patch"


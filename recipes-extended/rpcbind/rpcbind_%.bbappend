
# Disable rpcbind services
SYSTEMD_AUTO_ENABLE = "disable"
